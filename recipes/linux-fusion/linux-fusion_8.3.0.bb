require linux-fusion.inc 

PR = "r0"

SRC_URI[md5sum] = "28d49746f2e6acfb45c052dcd92d91ef"
SRC_URI[sha256sum] = "6897b86f4ef0770e24e7544b7faf27d426f0a56f4f31255208d17b9594c0ca3c"

