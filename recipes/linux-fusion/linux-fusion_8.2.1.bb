require linux-fusion.inc 

PR = "r0"

SRC_URI[md5sum] = "bc126aef15b9113e31705647c1bf8b76"
